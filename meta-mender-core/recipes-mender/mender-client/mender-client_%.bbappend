FILESEXTRAPATHS_prepend := "${THISDIR}/patches:"
SRC_URI_append = " file://allow_rebooting_in_commit_state.diff"
